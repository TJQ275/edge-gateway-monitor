# Keil uVision project F4project.uvprojx, settings and files
target F4project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x800C000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F4project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../code;../Lvgl;../Lvgl/examples/porting;../Lvgl/src;../Lvgl/LVGL_myGUI;../model;../ESP8266;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../SPI_Flash
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x800C000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group code
    ../code/: pin_config.h lcd.c lcd.h touch.c touch.h ota.c ota.h Taskhandel.c Taskhandel.h
  group LVGL_myGUI
    ../Lvgl/LVGL_myGUI/: page_main.c page_main.h font_chinese_9.c
  group LVGL_conf
    ../Lvgl/: lv_conf.h lvgl.h
  group LVGL_porting
    ../Lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.h lv_port_indev.c
  group LVGL_src
    ../Lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Lvgl/src/extra/others/msg/: lv_msg.c
    ../Lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Lvgl/src/extra/widgets/led/: lv_led.c
    ../Lvgl/src/extra/widgets/list/: lv_list.c
    ../Lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Lvgl/src/extra/widgets/span/: lv_span.c
    ../Lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Lvgl/src/extra/widgets/win/: lv_win.c
    ../Lvgl/src/extra/: lv_extra.c
    ../Lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group model
    ../model/: modbus.c modbus.h modbus_slave.c modbus_slave.h
  group ESP8266
    ../ESP8266/: command.c command.h ESP_at.c ESP_at.h pal.c pal.h
  group SPI_Flash
    ../SPI_Flash/: bsp_flash.c bsp_flash.h flash.c flash.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
